# Keil uVision project gpio.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: gpio +hex
  c flags: Optim=1
  c include: ..\HARDWARE\DELAY;..\HARDWARE\LCD1602
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
  group USER
    ../USER/: main.c
  group HARDWARE
    ../HARDWARE/LCD1602/: lcd1602.c
    ../HARDWARE/DELAY/: delay.c
